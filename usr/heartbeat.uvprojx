# Keil uVision project heartbeat.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: heartbeat +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\stdlib\CMSIS\CM3\CoreSupport;..\stdlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\stdlib\STM32F10x_StdPeriph_Driver\inc;..\HARDWARE\IIC;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USR
    ../stdlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h
    ../stdlib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_it.c
    ../stdlib/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_conf.h
    ./: main.c
  group FWLIB
    ../stdlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_rcc.c
  group CORE
    ../stdlib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../stdlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group SYS
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group HW
    ../HARDWARE/IIC/: algorithm.c max30102.c myiic.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
